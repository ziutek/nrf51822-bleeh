# Keil uVision project bleeh.uvprojx, settings and files
target bleeh (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: bleeh
  c flags: Optim=1
  c include: .\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source
    ./: nrf51_LPCOMP.c main.c nrf51_CLOCK.c nrf51_RTC.c nrf_delay_l85.c
  group debug
    ./debug/: SEGGER_RTT.c SEGGER_RTT_Printf.c
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
